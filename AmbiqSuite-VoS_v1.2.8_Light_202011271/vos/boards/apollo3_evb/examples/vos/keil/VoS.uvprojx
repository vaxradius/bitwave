# Keil uVision project VoS.uvprojx, settings and files
target DSPC_THF (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: VoS_DSPC_THF
  AfterMake: fromelf --bin --output bin\VoS_DSPC_THF.bin bin\VoS_DSPC_THF.axf
  AfterMake: fromelf -cedrst --output bin\VoS_DSPC_THF.txt bin\VoS_DSPC_THF.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_FREERTOS AM_PART_APOLLO3 AM_CUSTOM_BDADDR AM_PACKAGE_BGA AM_VOS_DSPC AM_VOS_THF CORE_M4 DSPC_CORTEX_M USE_BLE_OTA AM_BLE_USE_NVM SEC_ECC_CFG=SEC_ECC_CFG_UECC keil
  c include: ../../../../../../AmbiqSuite-KWD/ambiq_ble/apps/amvos;../../../../../../AmbiqSuite-KWD/ambiq_ble/profiles/amota;../../../../../../AmbiqSuite-KWD/ambiq_ble/services;../../../../../../AmbiqSuite-KWD/bootloader;../../../../../../AmbiqSuite-KWD/devices;../../../../../../AmbiqSuite-KWD/CMSIS/AmbiqMicro/Include;../../../../../../AmbiqSuite-KWD/CMSIS/ARM/Include;../../../../../../AmbiqSuite-KWD/mcu/apollo3;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/include;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/hci/ambiq/apollo3;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/hci/ambiq;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/sec/common;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/cfg;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/dm;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/hci;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/smp;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/include/app;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/apps/app;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/profiles/gatt;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/profiles/include;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/profiles;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/services;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/include;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources/port/freertos;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources/util;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources;../../../../../../AmbiqSuite-KWD/third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2;../../../../../../AmbiqSuite-KWD/third_party/FreeRTOSv10.1.1/Source/include;../../../../../../AmbiqSuite-KWD/third_party/uecc;../../../../../../AmbiqSuite-KWD/utils;../../../../../common/ama/inc;../../../../../common/codec/bluez;../../../../../common/codec/opus;../../../../../common/devices;../../../../../sys/app_utils;../../../../../sys/user_src;../../../../../sys/user_include;../../../../../third_party/DSPConcepts/AWECore/Include;../../../../../third_party/DSPConcepts/AWELayout;../../../../../third_party/Sensory/SensoryLib;../../../../../third_party/SystemView/Src/Config;../../../../../third_party/SystemView/Src/SEGGER;../../../../../third_party/SystemView/Src/Sample/OS;../../../bsp;../inc
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\VoS.sct
  group ama
    ../../../../../common/ama/: am_vos_ama_callback.c
    ../../../../../common/ama/keil/bin/: libama.lib
  group amvos
    ../../../../../common/codec/opus/: ae_api.c opuslib.lib
    ../../../../../../AmbiqSuite-KWD/ambiq_ble/apps/amota/: amota_main.c
    ../../../../../../AmbiqSuite-KWD/ambiq_ble/profiles/amota/: amotas_main.c
    ../../../../../../AmbiqSuite-KWD/ambiq_ble/apps/amvos/: amvos_main.c
    ../: main.c
    ../../../../../common/codec/bluez/: sbc.c
    ../../../../../../AmbiqSuite-KWD/ambiq_ble/services/: svc_amotas.c svc_amvos.c
  group am_hal_bsp
    ../../../../../../AmbiqSuite-KWD/bootloader/: am_bootloader.c am_multi_boot.c
    ../../../bsp/: am_bsp.c am_bsp_pins.c
    ../../../../../../AmbiqSuite-KWD/devices/: am_devices_led.c
    ../../../../../../AmbiqSuite-KWD/mcu/apollo3/hal/keil/bin/: libam_hal.lib
  group awe
    ../../../../../third_party/DSPConcepts/AWECore/Source/: am_vos_awe.c AWECoreUtils.c
    ../../../../../third_party/DSPConcepts/AWELayout/: apollo3p_2mic_remote_LMS_only_v4_InitAWB.c vos_alexa_qual_InitAWB.c
    ../../../../../third_party/DSPConcepts/AWECore/Lib/MDK-ARM/: AWECore.lib dspc-qsd.lib
  group ble
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/apps/app/common/: app_db.c app_hw.c app_ui.c ui_console.c ui_lcd.c ui_main.c ui_platform.c ui_timer.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/apps/app/: app_disc.c app_main.c app_master.c app_master_leg.c app_server.c app_slave.c app_slave_leg.c app_terminal.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/att/: att_main.c att_uuid.c attc_disc.c attc_main.c attc_proc.c attc_read.c attc_sign.c attc_write.c atts_ccc.c atts_csf.c atts_dyn.c atts_ind.c atts_main.c atts_proc.c atts_read.c atts_sign.c atts_write.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources/util/: bda.c bstream.c calc128.c crc32.c print.c terminal.c wstr.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/cfg/: cfg_stack.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/dm/: dm_adv.c dm_adv_ae.c dm_adv_leg.c dm_conn.c dm_conn_cte.c dm_conn_master.c dm_conn_master_ae.c dm_conn_master_leg.c dm_conn_slave.c dm_conn_slave_ae.c dm_conn_slave_leg.c dm_conn_sm.c dm_dev.c dm_dev_priv.c dm_main.c dm_past.c dm_phy.c dm_priv.c dm_scan.c dm_scan_ae.c dm_scan_leg.c dm_sec.c dm_sec_lesc.c dm_sec_master.c dm_sec_slave.c dm_sync_ae.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/profiles/gatt/: gatt_main.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/hci/ambiq/: hci_cmd.c hci_cmd_ae.c hci_cmd_cte.c hci_cmd_past.c hci_cmd_phy.c hci_core.c hci_core_ps.c hci_evt.c hci_tr.c hci_vs.c hci_vs_ae.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/hci/ambiq/apollo3/: hci_drv_apollo3.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/hci/: hci_main.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/l2c/: l2c_coc.c l2c_main.c l2c_master.c l2c_slave.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/sec/common/: sec_aes.c sec_aes_rev.c sec_ccm_hci.c sec_cmac_hci.c sec_ecc_debug.c sec_ecc_hci.c sec_main.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/sec/uecc/: sec_ecc.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/smp/: smp_act.c smp_db.c smp_main.c smp_non.c smp_sc_act.c smp_sc_main.c smpi_act.c smpi_sc_act.c smpi_sc_sm.c smpi_sm.c smpr_act.c smpr_sc_act.c smpr_sc_sm.c smpr_sm.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/services/: svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_cte.c svc_dis.c svc_gls.c svc_gyro.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_time.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
    ../../../../../../AmbiqSuite-KWD/third_party/uecc/: uECC.c uECC_ll.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources/port/freertos/: wsf_assert.c wsf_buf.c wsf_efs.c wsf_math.c wsf_msg.c wsf_os.c wsf_queue.c wsf_timer.c wsf_trace.c
  group cspotter
    ../../../../../third_party/Cyberon/keil/: CSpotter.c libCSpotter_16k24d.lib
  group dspotter
    ../../../../../third_party/Cyberon/keil/: DSpotter.c libDSpotter.lib CommandData_Keil.s LicenseData_Keil.s CommandData2_Keil.s
  group devices
    ../../../../../common/devices/: am_devices_amu2s.c am_devices_fxl6408.c am_devices_lis2dw12.c am_devices_vm3011.c
  group freertos
    ../../../../../../AmbiqSuite-KWD/third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../AmbiqSuite-KWD/third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_4.c
    ../../../../../../AmbiqSuite-KWD/third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2/: port.c
  group keil
    ../keil/: startup_keil.s
  group sys
    ../../../../../sys/app_utils/: am_app_digital_filter.c am_app_utils.c am_app_utils_buzzer.c am_app_utils_gsensor.c am_app_utils_ring_buffer.c am_app_utils_stdio.c am_app_utils_task.c
    ../../../../../sys/user_src/: am_audio_buffer.c am_vos_audio.c am_vos_ble.c am_vos_board_setup.c am_vos_codec.c am_vos_init.c am_vos_isr.c am_vos_logic.c am_vos_rtt_recorder.c am_vos_task.c uart_task.c
  group sysview
    ../../../../../third_party/SystemView/Src/SEGGER/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c
    ../../../../../third_party/SystemView/Src/Sample/Config/: SEGGER_SYSVIEW_Config_FreeRTOS.c
    ../../../../../third_party/SystemView/Src/Sample/OS/: SEGGER_SYSVIEW_FreeRTOS.c
  group thf
    ../../../../../third_party/Sensory/SensoryLib/: am_vos_SensoryTHF.c appAudio.c
    ../../../../../third_party/Sensory/SensoryLib/keil/: SensoryProcess_tb.lib Sensory_Ambiqmicro_CM4_v6.0.0_KeiluVision5.27.1.0_5June2019.lib
    ../../../../../third_party/Sensory/cmds/: sensory_x_music_en_US_sfs14_delivery01_am_st38.c sensory_x_music_en_US_sfs14_delivery01_search_7_st38.c
    ../../../../../third_party/Sensory/thfft_alexa_enus_v3c_dsp_64kb_pc40/: thfft_alexa_enus_v3c_dsp_64kb_am_pc40.c thfft_alexa_enus_v3c_dsp_64kb_search_2_pc40.c
  group utils
    ../../../../../../AmbiqSuite-KWD/utils/: am_util_ble.c am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
target DSPC_CSpotter (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: as above
  output: VoS_DSPC_CSpotter
  AfterMake: fromelf --bin --output bin\VoS_DSPC_CSpotter.bin bin\VoS_DSPC_CSpotter.axf
  AfterMake: fromelf -cedrst --output bin\VoS_DSPC_CSpotter.txt bin\VoS_DSPC_CSpotter.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_FREERTOS AM_PART_APOLLO3 AM_CUSTOM_BDADDR AM_PACKAGE_BGA AM_VOS_DSPC AM_VOS_CSPOTTER  CORE_M4 DSPC_CORTEX_M AM_BLE_USE_NVM SEC_ECC_CFG=SEC_ECC_CFG_UECC keil
  c include: ../../../../../../AmbiqSuite-KWD/ambiq_ble/apps/amvos;../../../../../../AmbiqSuite-KWD/ambiq_ble/profiles/amota;../../../../../../AmbiqSuite-KWD/ambiq_ble/services;../../../../../../AmbiqSuite-KWD/bootloader;../../../../../../AmbiqSuite-KWD/devices;../../../../../../AmbiqSuite-KWD/CMSIS/AmbiqMicro/Include;../../../../../../AmbiqSuite-KWD/CMSIS/ARM/Include;../../../../../../AmbiqSuite-KWD/mcu/apollo3;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/include;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/hci/ambiq/apollo3;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/hci/ambiq;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/sec/common;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/cfg;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/dm;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/hci;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/smp;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/include/app;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/apps/app;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/profiles/gatt;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/profiles/include;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/profiles;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/services;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/include;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources/port/freertos;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources/util;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources;../../../../../../AmbiqSuite-KWD/third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2;../../../../../../AmbiqSuite-KWD/third_party/FreeRTOSv10.1.1/Source/include;../../../../../../AmbiqSuite-KWD/third_party/uecc;../../../../../../AmbiqSuite-KWD/utils;../../../../../common/ama/inc;../../../../../common/codec/bluez;../../../../../common/codec/opus;../../../../../common/devices;../../../../../sys/app_utils;../../../../../sys/user_src;../../../../../sys/user_include;../../../../../third_party/Cyberon/Keil;../../../../../third_party/DSPConcepts/AWECore/Include;../../../../../third_party/DSPConcepts/AWELayout;../../../../../third_party/SystemView/Src/Config;../../../../../third_party/SystemView/Src/SEGGER;../../../../../third_party/SystemView/Src/Sample/OS;../../../bsp;../inc
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\VoS.sct
target DSPC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: as above
  output: VoS_DSPC
  AfterMake: fromelf --bin --output bin\VoS_DSPC.bin bin\VoS_DSPC.axf
  AfterMake: fromelf -cedrst --output bin\VoS_DSPC.txt bin\VoS_DSPC.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_FREERTOS AM_PART_APOLLO3 AM_CUSTOM_BDADDR AM_PACKAGE_BGA AM_VOS_DSPC CORE_M4 DSPC_CORTEX_M USE_BLE_OTA AM_BLE_USE_NVM SEC_ECC_CFG=SEC_ECC_CFG_UECC keil
  c include: ../../../../../../AmbiqSuite-KWD/ambiq_ble/apps/amvos;../../../../../../AmbiqSuite-KWD/ambiq_ble/profiles/amota;../../../../../../AmbiqSuite-KWD/ambiq_ble/services;../../../../../../AmbiqSuite-KWD/bootloader;../../../../../../AmbiqSuite-KWD/devices;../../../../../../AmbiqSuite-KWD/CMSIS/AmbiqMicro/Include;../../../../../../AmbiqSuite-KWD/CMSIS/ARM/Include;../../../../../../AmbiqSuite-KWD/mcu/apollo3;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/include;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/hci/ambiq/apollo3;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/hci/ambiq;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/sec/common;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/cfg;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/dm;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/hci;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/smp;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/include/app;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/apps/app;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/profiles/gatt;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/profiles/include;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/profiles;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/services;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/include;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources/port/freertos;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources/util;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources;../../../../../../AmbiqSuite-KWD/third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2;../../../../../../AmbiqSuite-KWD/third_party/FreeRTOSv10.1.1/Source/include;../../../../../../AmbiqSuite-KWD/third_party/uecc;../../../../../../AmbiqSuite-KWD/utils;../../../../../common/ama/inc;../../../../../common/codec/bluez;../../../../../common/codec/opus;../../../../../common/devices;../../../../../sys/app_utils;../../../../../sys/user_src;../../../../../sys/user_include;../../../../../third_party/DSPConcepts/AWECore/Include;../../../../../third_party/DSPConcepts/AWELayout;../../../../../third_party/SystemView/Src/Config;../../../../../third_party/SystemView/Src/SEGGER;../../../../../third_party/SystemView/Src/Sample/OS;../../../bsp;../inc
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\VoS.sct
target THF (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: as above
  output: VoS_THF
  AfterMake: fromelf --bin --output bin\VoS_THF.bin bin\VoS_THF.axf
  AfterMake: fromelf -cedrst --output bin\VoS_THF.txt bin\VoS_THF.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_FREERTOS AM_PART_APOLLO3 AM_CUSTOM_BDADDR AM_PACKAGE_BGA AM_VOS_THF USE_BLE_OTA AM_BLE_USE_NVM SEC_ECC_CFG=SEC_ECC_CFG_UECC keil
  c include: ../../../../../../AmbiqSuite-KWD/ambiq_ble/apps/amvos;../../../../../../AmbiqSuite-KWD/ambiq_ble/profiles/amota;../../../../../../AmbiqSuite-KWD/ambiq_ble/services;../../../../../../AmbiqSuite-KWD/bootloader;../../../../../../AmbiqSuite-KWD/devices;../../../../../../AmbiqSuite-KWD/CMSIS/AmbiqMicro/Include;../../../../../../AmbiqSuite-KWD/CMSIS/ARM/Include;../../../../../../AmbiqSuite-KWD/mcu/apollo3;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/include;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/hci/ambiq/apollo3;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/hci/ambiq;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/sec/common;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/cfg;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/dm;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/hci;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/smp;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/include/app;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/apps/app;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/profiles/gatt;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/profiles/include;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/profiles;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/services;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/include;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources/port/freertos;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources/util;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources;../../../../../../AmbiqSuite-KWD/third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2;../../../../../../AmbiqSuite-KWD/third_party/FreeRTOSv10.1.1/Source/include;../../../../../../AmbiqSuite-KWD/third_party/uecc;../../../../../../AmbiqSuite-KWD/utils;../../../../../common/ama/inc;../../../../../common/codec/bluez;../../../../../common/codec/opus;../../../../../common/devices;../../../../../sys/app_utils;../../../../../sys/user_src;../../../../../sys/user_include;../../../../../third_party/DSPConcepts/AWECore/Include;../../../../../third_party/Sensory/SensoryLib;../../../../../third_party/SystemView/Src/Config;../../../../../third_party/SystemView/Src/SEGGER;../../../../../third_party/SystemView/Src/Sample/OS;../../../bsp;../inc
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\VoS.sct
target CSpotter (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: as above
  output: VoS_CSpotter
  AfterMake: fromelf --bin --output bin\VoS_CSpotter.bin bin\VoS_CSpotter.axf
  AfterMake: fromelf -cedrst --output bin\VoS_CSpotter.txt bin\VoS_CSpotter.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_FREERTOS AM_PART_APOLLO3 AM_CUSTOM_BDADDR AM_PACKAGE_BGA AM_VOS_CSPOTTER AM_BLE_USE_NVM SEC_ECC_CFG=SEC_ECC_CFG_UECC keil
  c include: ../../../../../../AmbiqSuite-KWD/ambiq_ble/apps/amvos;../../../../../../AmbiqSuite-KWD/ambiq_ble/profiles/amota;../../../../../../AmbiqSuite-KWD/ambiq_ble/services;../../../../../../AmbiqSuite-KWD/bootloader;../../../../../../AmbiqSuite-KWD/devices;../../../../../../AmbiqSuite-KWD/CMSIS/AmbiqMicro/Include;../../../../../../AmbiqSuite-KWD/CMSIS/ARM/Include;../../../../../../AmbiqSuite-KWD/mcu/apollo3;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/include;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/hci/ambiq/apollo3;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/hci/ambiq;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/sec/common;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/cfg;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/dm;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/hci;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/smp;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/include/app;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/apps/app;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/profiles/gatt;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/profiles/include;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/profiles;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/services;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/include;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources/port/freertos;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources/util;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources;../../../../../../AmbiqSuite-KWD/third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2;../../../../../../AmbiqSuite-KWD/third_party/FreeRTOSv10.1.1/Source/include;../../../../../../AmbiqSuite-KWD/third_party/uecc;../../../../../../AmbiqSuite-KWD/utils;../../../../../common/ama/inc;../../../../../common/codec/bluez;../../../../../common/codec/opus;../../../../../common/devices;../../../../../sys/app_utils;../../../../../sys/user_src;../../../../../sys/user_include;../../../../../third_party/Cyberon/Keil;../../../../../third_party/DSPConcepts/AWECore/Include;../../../../../third_party/SystemView/Src/Config;../../../../../third_party/SystemView/Src/SEGGER;../../../../../third_party/SystemView/Src/Sample/OS;../../../bsp;../inc
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\VoS.sct
target Light (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: as above
  output: VoS_Light
  AfterMake: fromelf --bin --output bin\VoS_Light.bin bin\VoS_Light.axf
  AfterMake: fromelf -cedrst --output bin\VoS_Light.txt bin\VoS_Light.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_FREERTOS AM_PART_APOLLO3 AM_CUSTOM_BDADDR AM_PACKAGE_BGA USE_BLE_OTA AM_BLE_USE_NVM SEC_ECC_CFG=SEC_ECC_CFG_UECC keil
  c include: ../../../../../../AmbiqSuite-KWD/ambiq_ble/apps/amvos;../../../../../../AmbiqSuite-KWD/ambiq_ble/profiles/amota;../../../../../../AmbiqSuite-KWD/ambiq_ble/services;../../../../../../AmbiqSuite-KWD/bootloader;../../../../../../AmbiqSuite-KWD/devices;../../../../../../AmbiqSuite-KWD/CMSIS/AmbiqMicro/Include;../../../../../../AmbiqSuite-KWD/CMSIS/ARM/Include;../../../../../../AmbiqSuite-KWD/mcu/apollo3;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/include;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/hci/ambiq/apollo3;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/hci/ambiq;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/sec/common;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/cfg;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/dm;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/hci;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/smp;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/include/app;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/apps/app;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/profiles/gatt;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/profiles/include;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/profiles;../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/services;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/include;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources/port/freertos;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources/util;../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources;../../../../../../AmbiqSuite-KWD/third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2;../../../../../../AmbiqSuite-KWD/third_party/FreeRTOSv10.1.1/Source/include;../../../../../../AmbiqSuite-KWD/third_party/uecc;../../../../../../AmbiqSuite-KWD/utils;../../../../../common/ama/inc;../../../../../common/codec/bluez;../../../../../common/codec/opus;../../../../../common/devices;../../../../../sys/app_utils;../../../../../sys/user_src;../../../../../sys/user_include;../../../../../third_party/SystemView/Src/Config;../../../../../third_party/SystemView/Src/SEGGER;../../../../../third_party/SystemView/Src/Sample/OS;../../../bsp;../inc
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\VoS.sct
target DSpotter (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: as above
  output: VoS_DSpotter
  AfterMake: fromelf --bin --output bin\VoS_DSpotter.bin bin\VoS_DSpotter.axf
  AfterMake: fromelf -cedrst --output bin\VoS_DSpotter.txt bin\VoS_DSpotter.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_FREERTOS AM_PART_APOLLO3 AM_CUSTOM_BDADDR AM_PACKAGE_BGA AM_VOS_DSPOTTER AM_BLE_USE_NVM SEC_ECC_CFG=SEC_ECC_CFG_UECC keil
  c include: as above
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\VoS.sct
software components: CMSIS:DSP 1.6.0
