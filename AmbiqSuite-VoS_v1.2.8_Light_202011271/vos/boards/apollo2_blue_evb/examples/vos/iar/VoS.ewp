# IAR project VoS.ewp, settings and files
configuration DSPC_THF (ARM, debug)
  General.OGChipSelectEditMenu: AMAPH1KK-KBR AmbiqMicro AMAPH1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO2; AM_FREERTOS; AM_VOS_DSPC; AM_VOS_THF; CORE_M4; DSPC_CORTEX_M; HCI_APOLLO_USE_CUSTOMER_OWN_MAC=1; AM_BLE_USE_NVM; SEC_ECC_CFG=SEC_ECC_CFG_UECC
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\AmbiqSuite-KWD; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\apps\amvos; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\em9304; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\profiles\amota; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\services; ..\..\..\..\..\..\AmbiqSuite-KWD\bootloader; ..\..\..\..\..\..\AmbiqSuite-KWD\devices; ..\..\..\..\..\..\AmbiqSuite-KWD\mcu\apollo2; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\hci\ambiq; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\sec\common; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\cfg; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\dm; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\hci; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\smp; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\include\app; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\apps\app; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\profiles\gatt; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\profiles\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\profiles; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\services; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\sources\port\freertos; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\sources\util; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\sources; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOSv10.1.1\Source\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo2; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOSv10.1.1\Source\portable\MemMang; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\uecc; ..\..\..\..\..\..\AmbiqSuite-KWD\utils; ..\..\..\..\..\common\ama\inc; ..\..\..\..\..\common\codec\bluez; ..\..\..\..\..\common\codec\opus; ..\..\..\..\..\common\devices; ..\..\..\..\..\sys\app_utils; ..\..\..\..\..\sys\user_include; ..\..\..\..\..\third_party\DSPConcepts\AWECore\Include; ..\..\..\..\..\third_party\DSPConcepts\AWELayout; ..\..\..\..\..\third_party\Sensory\SensoryLib; ..\..\..\..\..\third_party\SystemView\Src\Config; ..\..\..\..\..\third_party\SystemView\Src\SEGGER; ..\..\..\..\..\third_party\SystemView\Src\Sample\Config; ..\..\..\..\..\third_party\SystemView\Src\Sample\OS; ..\..\..\..\..\third_party\SystemView\Src\Sample\FreeRTOSV9; ..\..\..\..\..\third_party\U-comm; ..\..\..\bsp; ..\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc; ..\..\..\..\..\..\AmbiqSuite-KWD; ..\..\..\..\..\..\AmbiqSuite-KWD\utils; ..\..\..\..\..\..\AmbiqSuite-KWD\mcu\apollo2; ..\..\..\..\..\..\AmbiqSuite-KWD\devices; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOS9\Source\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOS9\Source\portable\IAR\AMapollo2; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOS9\Source\portable\MemMang; ..\..\..\..\..\sys\user_include; ..\..\..\..\..\sys\app_utils; ..\..\..\..\..\third_party\SystemView\Src\Config; ..\..\..\..\..\third_party\SystemView\Src\SEGGER; ..\..\..\..\..\third_party\SystemView\Src\Sample\Config; ..\..\..\..\..\third_party\SystemView\Src\Sample\OS
  OBJCOPY.OOCOutputFile: VoS_DSPC_THF.bin
  ILINK.IlinkOutputFile: VoS_DSPC_THF.out
  ILINK.IlinkIcfFile: VoS.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DSPC (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO2; AM_FREERTOS; AM_VOS_DSPC; CORE_M4; DSPC_CORTEX_M; HCI_APOLLO_USE_CUSTOMER_OWN_MAC=1; AM_BLE_USE_NVM; SEC_ECC_CFG=SEC_ECC_CFG_UECC
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\AmbiqSuite-KWD; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\apps\amvos; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\em9304; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\profiles\amota; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\services; ..\..\..\..\..\..\AmbiqSuite-KWD\bootloader; ..\..\..\..\..\..\AmbiqSuite-KWD\devices; ..\..\..\..\..\..\AmbiqSuite-KWD\mcu\apollo2; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\hci\ambiq; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\sec\common; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\cfg; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\dm; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\hci; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\smp; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\include\app; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\apps\app; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\profiles\gatt; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\profiles\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\profiles; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\services; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\sources\port\freertos; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\sources\util; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\sources; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOSv10.1.1\Source\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo2; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOSv10.1.1\Source\portable\MemMang; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\uecc; ..\..\..\..\..\..\AmbiqSuite-KWD\utils; ..\..\..\..\..\common\ama\inc; ..\..\..\..\..\common\codec\bluez; ..\..\..\..\..\common\codec\opus; ..\..\..\..\..\common\devices; ..\..\..\..\..\sys\app_utils; ..\..\..\..\..\sys\user_include; ..\..\..\..\..\third_party\DSPConcepts\AWECore\Include; ..\..\..\..\..\third_party\DSPConcepts\AWELayout; ..\..\..\..\..\third_party\SystemView\Src\Config; ..\..\..\..\..\third_party\SystemView\Src\SEGGER; ..\..\..\..\..\third_party\SystemView\Src\Sample\Config; ..\..\..\..\..\third_party\SystemView\Src\Sample\OS; ..\..\..\..\..\third_party\SystemView\Src\Sample\FreeRTOSV9; ..\..\..\..\..\third_party\U-comm; ..\..\..\bsp; ..\inc
  OBJCOPY.OOCOutputFile: VoS_DSPC.bin
  ILINK.IlinkOutputFile: VoS_DSPC.out
configuration THF (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO2; AM_FREERTOS; AM_VOS_THF; CORE_M4; DSPC_CORTEX_M; HCI_APOLLO_USE_CUSTOMER_OWN_MAC=1; AM_BLE_USE_NVM; SEC_ECC_CFG=SEC_ECC_CFG_UECC
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\AmbiqSuite-KWD; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\apps\amvos; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\em9304; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\profiles\amota; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\services; ..\..\..\..\..\..\AmbiqSuite-KWD\bootloader; ..\..\..\..\..\..\AmbiqSuite-KWD\devices; ..\..\..\..\..\..\AmbiqSuite-KWD\mcu\apollo2; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\hci\ambiq; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\sec\common; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\cfg; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\dm; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\hci; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\smp; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\include\app; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\apps\app; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\profiles\gatt; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\profiles\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\profiles; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\services; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\sources\port\freertos; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\sources\util; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\sources; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOSv10.1.1\Source\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo2; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOSv10.1.1\Source\portable\MemMang; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\uecc; ..\..\..\..\..\..\AmbiqSuite-KWD\utils; ..\..\..\..\..\common\ama\inc; ..\..\..\..\..\common\codec\bluez; ..\..\..\..\..\common\codec\opus; ..\..\..\..\..\common\devices; ..\..\..\..\..\sys\app_utils; ..\..\..\..\..\sys\user_include; ..\..\..\..\..\third_party\DSPConcepts\AWECore\Include; ..\..\..\..\..\third_party\Sensory\SensoryLib; ..\..\..\..\..\third_party\SystemView\Src\Config; ..\..\..\..\..\third_party\SystemView\Src\SEGGER; ..\..\..\..\..\third_party\SystemView\Src\Sample\Config; ..\..\..\..\..\third_party\SystemView\Src\Sample\OS; ..\..\..\..\..\third_party\SystemView\Src\Sample\FreeRTOSV9; ..\..\..\..\..\third_party\U-comm; ..\..\..\bsp; ..\inc
  OBJCOPY.OOCOutputFile: VoS_THF.bin
  ILINK.IlinkOutputFile: VoS_THF.out
configuration RDSP (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO2; AM_FREERTOS; AM_VOS_RDSP; HCI_APOLLO_USE_CUSTOMER_OWN_MAC=1; AM_BLE_USE_NVM; SEC_ECC_CFG=SEC_ECC_CFG_UECC; __FPU_PRESENT; RDSP_DISABLE_FILEIO
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\AmbiqSuite-KWD; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\apps\amvos; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\em9304; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\profiles\amota; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\services; ..\..\..\..\..\..\AmbiqSuite-KWD\bootloader; ..\..\..\..\..\..\AmbiqSuite-KWD\devices; ..\..\..\..\..\..\AmbiqSuite-KWD\mcu\apollo2; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\hci\ambiq; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\sec\common; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\cfg; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\dm; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\hci; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\smp; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\include\app; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\apps\app; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\profiles\gatt; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\profiles\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\profiles; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\services; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\sources\port\freertos; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\sources\util; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\sources; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOSv10.1.1\Source\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo2; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOSv10.1.1\Source\portable\MemMang; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\uecc; ..\..\..\..\..\..\AmbiqSuite-KWD\utils; ..\..\..\..\..\common\ama\inc; ..\..\..\..\..\common\codec\bluez; ..\..\..\..\..\common\codec\opus; ..\..\..\..\..\common\devices; ..\..\..\..\..\sys\app_utils; ..\..\..\..\..\sys\user_include; ..\..\..\..\..\third_party\DSPConcepts\AWECore\Include; ..\..\..\..\..\third_party\Retune_DSP\CMSIS_5-5.5.1\CMSIS\NN\Include; ..\..\..\..\..\third_party\Retune_DSP\include; ..\..\..\..\..\third_party\Retune_DSP\include\public; ..\..\..\..\..\third_party\Retune_DSP\models\Alexa\EN-US; ..\..\..\..\..\third_party\Sensory\SensoryLib; ..\..\..\..\..\third_party\SystemView\Src\Config; ..\..\..\..\..\third_party\SystemView\Src\SEGGER; ..\..\..\..\..\third_party\SystemView\Src\Sample\Config; ..\..\..\..\..\third_party\SystemView\Src\Sample\OS; ..\..\..\..\..\third_party\SystemView\Src\Sample\FreeRTOSV9; ..\..\..\..\..\third_party\U-comm; ..\..\..\bsp; ..\inc
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: VoS_RDSP.bin
  ILINK.IlinkOutputFile: VoS_RDSP.out
  ILINK.IlinkExtraOptions: --redirect __iar_vla_alloc2=pvPortMalloc; --redirect __iar_vla_dealloc2=vPortFree; --redirect realloc=_not_implemented; --redirect calloc=_not_implemented
configuration AID (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO2; AM_FREERTOS; HCI_APOLLO_USE_CUSTOMER_OWN_MAC=1; AM_VOS_AID; AM_BLE_USE_NVM; SEC_ECC_CFG=SEC_ECC_CFG_UECC
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\AmbiqSuite-KWD; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\apps\amvos; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\em9304; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\profiles\amota; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\services; ..\..\..\..\..\..\AmbiqSuite-KWD\bootloader; ..\..\..\..\..\..\AmbiqSuite-KWD\devices; ..\..\..\..\..\..\AmbiqSuite-KWD\mcu\apollo2; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\hci\ambiq; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\sec\common; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\cfg; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\dm; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\hci; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\smp; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\include\app; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\apps\app; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\profiles\gatt; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\profiles\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\profiles; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\services; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\sources\port\freertos; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\sources\util; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\sources; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOSv10.1.1\Source\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo2; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOSv10.1.1\Source\portable\MemMang; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\uecc; ..\..\..\..\..\..\AmbiqSuite-KWD\utils; ..\..\..\..\..\common\ama\inc; ..\..\..\..\..\common\codec\bluez; ..\..\..\..\..\common\codec\opus; ..\..\..\..\..\common\devices; ..\..\..\..\..\sys\app_utils; ..\..\..\..\..\sys\user_include; ..\..\..\..\..\third_party\DSPConcepts\AWECore\Include; ..\..\..\..\..\third_party\SystemView\Src\Config; ..\..\..\..\..\third_party\SystemView\Src\SEGGER; ..\..\..\..\..\third_party\SystemView\Src\Sample\Config; ..\..\..\..\..\third_party\SystemView\Src\Sample\OS; ..\..\..\..\..\third_party\SystemView\Src\Sample\FreeRTOSV9; ..\..\..\..\..\third_party\U-comm; ..\..\..\bsp; ..\inc
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: VoS_AID.bin
  ILINK.IlinkOutputFile: VoS_AID.out
configuration Light (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO2; AM_FREERTOS; HCI_APOLLO_USE_CUSTOMER_OWN_MAC=1; AM_BLE_USE_NVM; SEC_ECC_CFG=SEC_ECC_CFG_UECC
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\AmbiqSuite-KWD; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\apps\amvos; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\em9304; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\profiles\amota; ..\..\..\..\..\..\AmbiqSuite-KWD\ambiq_ble\services; ..\..\..\..\..\..\AmbiqSuite-KWD\bootloader; ..\..\..\..\..\..\AmbiqSuite-KWD\devices; ..\..\..\..\..\..\AmbiqSuite-KWD\mcu\apollo2; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\hci\ambiq; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\sec\common; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\cfg; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\dm; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\hci; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-host\sources\stack\smp; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\include\app; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\apps\app; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\profiles\gatt; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\profiles\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\profiles; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\ble-profiles\sources\services; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\sources\port\freertos; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\sources\util; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\exactle\wsf\sources; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOSv10.1.1\Source\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo2; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOSv10.1.1\Source\portable\MemMang; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\uecc; ..\..\..\..\..\..\AmbiqSuite-KWD\utils; ..\..\..\..\..\common\ama\inc; ..\..\..\..\..\common\codec\bluez; ..\..\..\..\..\common\codec\opus; ..\..\..\..\..\common\devices; ..\..\..\..\..\sys\app_utils; ..\..\..\..\..\sys\user_include; ..\..\..\..\..\third_party\SystemView\Src\Config; ..\..\..\..\..\third_party\SystemView\Src\SEGGER; ..\..\..\..\..\third_party\SystemView\Src\Sample\Config; ..\..\..\..\..\third_party\SystemView\Src\Sample\OS; ..\..\..\..\..\third_party\SystemView\Src\Sample\FreeRTOSV9; ..\..\..\..\..\third_party\U-comm; ..\..\..\bsp; ..\inc
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: VoS_Light.bin
  ILINK.IlinkOutputFile: VoS_Light.out
configuration DSPC_THF_OTA (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO2; AM_FREERTOS; AM_VOS_DSPC; AM_VOS_THF; CORE_M4; DSPC_CORTEX_M; USE_BLE_OTA; HCI_APOLLO_USE_CUSTOMER_OWN_MAC=1; SEC_ECC_CFG=SEC_ECC_CFG_UECC
  AARM.AUserIncludes: ..\inc; ..\..\..\..\..\..\AmbiqSuite-KWD; ..\..\..\..\..\..\AmbiqSuite-KWD\utils; ..\..\..\..\..\..\mcu\apollo2; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOS9\Source\include; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOS9\Source\portable\IAR\AMapollo2; ..\..\..\..\..\..\AmbiqSuite-KWD\third_party\FreeRTOS9\Source\portable\MemMang; ..\..\..\..\..\sys\user_include; ..\..\..\..\..\sys\app_utils; ..\..\..\..\..\third_party\SystemView\Src\Config; ..\..\..\..\..\third_party\SystemView\Src\SEGGER; ..\..\..\..\..\third_party\SystemView\Src\Sample\Config; ..\..\..\..\..\third_party\SystemView\Src\Sample\OS
  OBJCOPY.OOCOutputFile: VoS_DSPC_THF_OTA.bin
  ILINK.IlinkOutputFile: VoS_DSPC_THF_OTA.out
  ILINK.IlinkIcfFile: VoS_OTA.icf
configuration DSPC_OTA (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO2; AM_FREERTOS; AM_VOS_DSPC; CORE_M4; DSPC_CORTEX_M; USE_BLE_OTA; HCI_APOLLO_USE_CUSTOMER_OWN_MAC=1; AM_BLE_USE_NVM; SEC_ECC_CFG=SEC_ECC_CFG_UECC
  ICCARM.CCIncludePath2: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: VoS_DSPC_OTA.bin
  ILINK.IlinkOutputFile: VoS_DSPC_OTA.out
  ILINK.IlinkIcfFile: VoS_OTA.icf
configuration THF_OTA (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO2; AM_FREERTOS; AM_VOS_THF; CORE_M4; DSPC_CORTEX_M; USE_BLE_OTA; HCI_APOLLO_USE_CUSTOMER_OWN_MAC=1; AM_BLE_USE_NVM; SEC_ECC_CFG=SEC_ECC_CFG_UECC
  ICCARM.CCIncludePath2: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: VoS_THF_OTA.bin
  ILINK.IlinkOutputFile: VoS_THF_OTA.out
  ILINK.IlinkIcfFile: VoS_OTA.icf
configuration Light_OTA (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO2; AM_FREERTOS; USE_BLE_OTA; HCI_APOLLO_USE_CUSTOMER_OWN_MAC=1; AM_BLE_USE_NVM; SEC_ECC_CFG=SEC_ECC_CFG_UECC
  ICCARM.CCIncludePath2: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: VoS_Light_OTA.bin
  ILINK.IlinkOutputFile: VoS_Light_OTA.out
  ILINK.IlinkIcfFile: VoS_OTA.icf
  group (top)
    ../: main.c
    ./: startup_iar.c
  group am_hal_bsp
    ../../../../../../AmbiqSuite-KWD/bootloader/: am_bootloader.c am_multi_boot.c
    ../../../bsp/: am_bsp.c
    ../../../../../../AmbiqSuite-KWD/devices/: am_devices_led.c
    ../../../../../../AmbiqSuite-KWD/mcu/apollo2/hal/iar/bin/: libam_hal.a
  group ama
    ../../../../../common/ama/: am_vos_ama_callback.c
    ../../../../../common/ama/iar/bin/: libama.a
  group awe
    ../../../../../third_party/DSPConcepts/AWECore/Source/: am_vos_awe.c AWECoreUtils.c
    ../../../../../third_party/DSPConcepts/AWELayout/: apollo3p_2mic_remote_LMS_only_v4_InitAWB.c vos_alexa_qual_InitAWB.c
    ../../../../../third_party/DSPConcepts/AWECore/Lib/EWARM/: AWECore.a dspc_qsd.a
  group ble
    ../../../../../../AmbiqSuite-KWD/ambiq_ble/apps/amvos/: amvos_main.c
    ../../../../../../AmbiqSuite-KWD/ambiq_ble/services/: svc_amvos.c
  group ble/ota
    ../../../../../../AmbiqSuite-KWD/ambiq_ble/apps/amota/: amota_main.c
    ../../../../../../AmbiqSuite-KWD/ambiq_ble/profiles/amota/: amotas_main.c
    ../../../../../../AmbiqSuite-KWD/ambiq_ble/services/: svc_amotas.c
  group ble/stack
    ../../../../../../AmbiqSuite-KWD/devices/: am_devices_em9304.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/apps/app/common/: app_db.c app_hw.c app_ui.c ui_console.c ui_lcd.c ui_main.c ui_platform.c ui_timer.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/apps/app/: app_disc.c app_main.c app_master.c app_master_leg.c app_server.c app_slave.c app_slave_leg.c app_terminal.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/att/: att_main.c att_uuid.c attc_disc.c attc_main.c attc_proc.c attc_read.c attc_sign.c attc_write.c atts_ccc.c atts_csf.c atts_dyn.c atts_ind.c atts_main.c atts_proc.c atts_read.c atts_sign.c atts_write.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources/util/: bda.c bstream.c calc128.c crc32.c print.c terminal.c wstr.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/cfg/: cfg_stack.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/dm/: dm_adv.c dm_adv_ae.c dm_adv_leg.c dm_conn.c dm_conn_cte.c dm_conn_master.c dm_conn_master_ae.c dm_conn_master_leg.c dm_conn_slave.c dm_conn_slave_ae.c dm_conn_slave_leg.c dm_conn_sm.c dm_dev.c dm_dev_priv.c dm_main.c dm_past.c dm_phy.c dm_priv.c dm_scan.c dm_scan_ae.c dm_scan_leg.c dm_sec.c dm_sec_lesc.c dm_sec_master.c dm_sec_slave.c dm_sync_ae.c
    ../../../../../../AmbiqSuite-KWD/ambiq_ble/em9304/: em9304_init.c em9304_patches.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/profiles/gatt/: gatt_main.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/hci/ambiq/: hci_cmd.c hci_cmd_ae.c hci_cmd_cte.c hci_cmd_past.c hci_cmd_phy.c hci_core.c hci_core_ps.c hci_evt.c hci_tr.c hci_vs.c hci_vs_ae.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/hci/ambiq/em9304/: hci_drv_em9304.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/hci/: hci_main.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/l2c/: l2c_coc.c l2c_main.c l2c_master.c l2c_slave.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/sec/common/: sec_aes.c sec_aes_rev.c sec_ccm_hci.c sec_cmac_hci.c sec_ecc_debug.c sec_ecc_hci.c sec_main.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/sec/uecc/: sec_ecc.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-host/sources/stack/smp/: smp_act.c smp_db.c smp_main.c smp_non.c smp_sc_act.c smp_sc_main.c smpi_act.c smpi_sc_act.c smpi_sc_sm.c smpi_sm.c smpr_act.c smpr_sc_act.c smpr_sc_sm.c smpr_sm.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/ble-profiles/sources/services/: svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_dis.c svc_gls.c svc_gyro.c svc_hid.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_time.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
    ../../../../../../AmbiqSuite-KWD/third_party/uecc/: uECC.c uECC_ll.c
    ../../../../../../AmbiqSuite-KWD/third_party/exactle/wsf/sources/port/freertos/: wsf_assert.c wsf_buf.c wsf_efs.c wsf_math.c wsf_msg.c wsf_os.c wsf_queue.c wsf_timer.c wsf_trace.c
  group codec
    ../../../../../common/codec/opus/: ae_api.c libopus.a
    ../../../../../common/codec/bluez/: sbc.c
  group devices
    ../../../../../common/devices/: am_devices_lis2dw12.c am_devices_vm3011.c
  group freertos
    ../../../../../../AmbiqSuite-KWD/third_party/FreeRTOSv10.1.1/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../AmbiqSuite-KWD/third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_4.c
    ../../../../../../AmbiqSuite-KWD/third_party/FreeRTOSv10.1.1/Source/portable/IAR/AMapollo2/: port.c portasm.s
  group oal
    ../../../../../third_party/OAL/: am_vos_oal_aid.c libaid_awaken_xzxz_no_limit_v108.a
  group ovvp
    ../../../../../third_party/U-comm/: ambiq_apollo2_click23_190614.a ambiq_ovvp_lib_191128.a sensor_st.a
  group rdsp
    ../../../../../third_party/Retune_DSP/: am_vos_RetuneDSP.c
  group rdsp/cmsis_nn
    ../../../../../third_party/Retune_DSP/CMSIS_5-5.5.1/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c
    ../../../../../third_party/Retune_DSP/CMSIS_5-5.5.1/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q15.c arm_nn_activations_q7.c arm_relu_q15.c arm_relu_q7.c
    ../../../../../third_party/Retune_DSP/CMSIS_5-5.5.1/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_mult_q15.c arm_nn_mult_q7.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c
  group rdsp/lib_1hr
    ../../../../../third_party/Retune_DSP/lib/: libRDSP_VS_MODEL_CM4_IAR.a libRDSP_VS_VOICESPOT_CM4_IAR.a
  group rdsp/lib_chipid
    ../../../../../third_party/Retune_DSP/lib/25h-uni-lib/: libRDSP_VS_MODEL_CM4_IAR.a libRDSP_VS_VOICESPOT_CM4_IAR.a
  group rdsp/vad_chipid_lib
    ../../../../../third_party/Retune_DSP/lib/vad_chipid_lib/: libRDSP_VS_MODEL_CM4.a libRDSP_VS_VOICESPOT_CM4.a
  group sys/app_utils
    ../../../../../sys/app_utils/: am_app_utils.c am_app_utils_gsensor.c am_app_utils_ring_buffer.c am_app_utils_stdio.c am_app_utils_task.c
    ../../../../../sys/user_src/: am_audio_buffer.c
  group sys/user_src
    ../../../../../sys/user_src/: am_vos_audio.c am_vos_ble.c am_vos_board_setup.c am_vos_codec.c am_vos_init.c am_vos_isr.c am_vos_logic.c am_vos_rtt_recorder.c am_vos_task.c
  group sysview
    ../../../../../third_party/SystemView/Src/SEGGER/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c
    ../../../../../third_party/SystemView/Src/Sample/Config/: SEGGER_SYSVIEW_Config_FreeRTOS.c
    ../../../../../third_party/SystemView/Src/Sample/OS/: SEGGER_SYSVIEW_FreeRTOS.c
  group thf
    ../../../../../third_party/Sensory/SensoryLib/: am_vos_SensoryTHF.c appAudio.c
    ../../../../../third_party/Sensory/SensoryLib/iar/: Sensory_Ambiqmicro_CM4_v6.0.0_IAR8.32.2_5June2019.a SensoryProcess_tb.a
    ../../../../../third_party/Sensory/cmds/: sensory_x_music_en_US_sfs14_delivery01_am_st38.c sensory_x_music_en_US_sfs14_delivery01_search_7_st38.c
    ../../../../../third_party/Sensory/thfft_alexa_enus_v3c_dsp_64kb_pc40/: thfft_alexa_enus_v3c_dsp_64kb_am_pc40.c thfft_alexa_enus_v3c_dsp_64kb_search_2_pc40.c
  group utils
    ../../../../../../AmbiqSuite-KWD/utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_regdump.c am_util_stdio.c am_util_string.c am_util_time.c
