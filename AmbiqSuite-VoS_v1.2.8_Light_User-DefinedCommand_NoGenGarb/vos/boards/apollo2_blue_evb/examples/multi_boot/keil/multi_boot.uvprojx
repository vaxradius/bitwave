# Keil uVision project multi_boot.uvprojx, settings and files
target multi_boot (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(24000000) ELITTLE
  output: multi_boot
  AfterMake: fromelf --bin --output bin\multi_boot.bin bin\multi_boot.axf
  AfterMake: fromelf -cedrst --output bin\multi_boot.txt bin\multi_boot.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_MULTIBOOT_CONFIG_FILE=\"am_multi_boot_config.h\" AM_PART_APOLLO2 keil AM_DEBUG_PRINTF AM_MULTI_BOOT BOOTLOADER_DEBUG
  c include: ../src;../../../bsp;../../../../..;../../../../../utils;../../../../../devices;../../../../../bootloader;../../../../../mcu/apollo2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: .\multi_boot.sct
  link misc: ../../../../../mcu/apollo2/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: extflash.c multi_boot.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_stdio.c
  group devices
    ../../../../../devices/: am_devices_spiflash.c
  group bootloader
    ../../../../../bootloader/: am_bootloader.c am_ios_boot_handlers.c am_multi_boot.c am_uart_boot_handlers.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../mcu/apollo2/hal/keil/bin/: libam_hal.lib
  group bsp
    ../../../bsp/: am_bsp.c
